# Keil uVision project AT89C51.uvproj, settings and files
target Electronic (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 89C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  group Doc
    ../: readme.md
  group Startup
    ../Startup/: STARTUP.A51
  group User
    ../User/: main.c bsp_delay.c bsp_key.c bsp_ds1302.c
